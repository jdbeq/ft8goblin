options:
  parameters:
    author: Dangerous Devices
    copyright: 2023 Dangerous Devices
    description: This flowgraph captures and streams all the HF ft8 subbands to external decoder processes via UDP
    generate_options: qt_gui
    id: ft8capture
    output_language: python
    title: ft8 mass decoder
  states: {}

blocks:
- name: antenna
  id: variable
  parameters:
    value: '"RX2"'
  states: {}
- name: cfg
  id: json_config
  parameters:
    config_file: /home/joseph/ft8md/config.json
  states: {state: disabled}
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: ft8_10m
  id: variable
  parameters:
    value: '28074000'
  states: {}
- name: ft8_12m
  id: variable
  parameters:
    value: '24915000'
  states: {}
- name: ft8_15m
  id: variable
  parameters:
    value: '21074000'
  states: {}
- name: ft8_160m
  id: variable
  parameters:
    value: '1084000'
  states: {}
- name: ft8_17m
  id: variable
  parameters:
    value: '18100000'
  states: {}
- name: ft8_20m
  id: variable
  parameters:
    value: '14074000'
  states: {}
- name: ft8_30m
  id: variable
  parameters:
    value: '10133000'
  states: {}
- name: ft8_40m
  id: variable
  parameters:
    value: '7074000'
  states: {}
- name: ft8_60m
  id: variable
  parameters:
    value: '5357000'
  states: {}
- name: ft8_80m
  id: variable
  parameters:
    value: '3573000'
  states: {}
- name: rf_bandwidth
  id: variable
  parameters:
    value: '29000000'
  states: {}
- name: rf_center
  id: variable
  parameters:
    value: rf_bandwidth/2
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '16'
  states: {}
- name: rf_samp_rate
  id: variable
  parameters:
    value: '33333333'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: slot_width
  id: variable
  parameters:
    value: '3500'
  states: {}
- name: waterfall_update_band
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: waterfall_update_main
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ft8_160m - (samp_rate * 0.5)
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), slot_width)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ft8_80m - (samp_rate * 0.5)
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), slot_width)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_2
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ft8_60m - (samp_rate * 0.5)
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), slot_width)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_3
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ft8_40m - (samp_rate * 0.5)
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), slot_width)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_3_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ft8_20m - (samp_rate * 0.5)
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), slot_width)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_3_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ft8_17m - (samp_rate * 0.5)
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), slot_width)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_3_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ft8_17m - (samp_rate * 0.5)
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), slot_width)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_3_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ft8_15m - (samp_rate * 0.5)
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), slot_width)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_3_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ft8_12m - (samp_rate * 0.5)
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), slot_width)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_3_0_0_0_0_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: ft8_10m - (samp_rate * 0.5)
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.complex_band_pass(1, samp_rate, -samp_rate/(2*decimation), samp_rate/(2*decimation), slot_width)
    type: ccc
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '12001'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_1
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '12002'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_2
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '12003'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_3
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '13004'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_3_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '13004'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_3_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '13004'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_3_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '13004'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_3_0_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '13004'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_3_0_0_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '13004'
    send_eof: 'False'
    type: complex
  states: {}
- name: network_udp_sink_3_0_0_0_0_0_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '13004'
    send_eof: 'False'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: rf_bandwidth
    color1: '6'
    fc: rf_center
    fftsize: '2048'
    grid: 'True'
    gui_hint: '[0,0,1,2]'
    legend: 'False'
    type: complex
    update_time: waterfall_update_main
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: slot_width
    fc: slot_width * 0.5
    fftsize: '1024'
    grid: 'True'
    gui_hint: '[1,0,1,1]'
    legend: 'False'
    type: complex
    update_time: waterfall_update_band
  states: {}
- name: qtgui_waterfall_sink_x_2
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: slot_width
    fc: slot_width * 0.5
    fftsize: '1024'
    gui_hint: '[1,1,1,1]'
    legend: 'False'
    type: complex
    update_time: waterfall_update_band
  states: {}
- name: qtgui_waterfall_sink_x_3
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: slot_width
    fc: slot_width * 0.5
    fftsize: '1024'
    grid: 'True'
    gui_hint: '[2,0,1,1]'
    legend: 'False'
    type: complex
    update_time: waterfall_update_band
  states: {}
- name: qtgui_waterfall_sink_x_4
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: slot_width
    fc: slot_width * 0.5
    fftsize: '1024'
    grid: 'True'
    gui_hint: '[2,1,1,1]'
    legend: 'False'
    type: complex
    update_time: waterfall_update_band
  states: {}
- name: qtgui_waterfall_sink_x_4_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: slot_width
    fc: slot_width * 0.5
    fftsize: '1024'
    grid: 'True'
    gui_hint: '[3,0,1,1]'
    legend: 'False'
    type: complex
    update_time: waterfall_update_band
  states: {}
- name: qtgui_waterfall_sink_x_4_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: slot_width
    fc: slot_width * 0.5
    fftsize: '1024'
    grid: 'True'
    gui_hint: '[3,1,1,1]'
    legend: 'False'
    type: complex
    update_time: waterfall_update_band
  states: {}
- name: qtgui_waterfall_sink_x_4_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: slot_width
    fc: slot_width * 0.5
    fftsize: '1024'
    grid: 'True'
    gui_hint: '[4,0,1,1]'
    legend: 'False'
    type: complex
    update_time: waterfall_update_band
  states: {}
- name: qtgui_waterfall_sink_x_4_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: slot_width
    fc: slot_width * 0.5
    fftsize: '1024'
    grid: 'True'
    gui_hint: '[4,1,1,1]'
    legend: 'False'
    type: complex
    update_time: waterfall_update_band
  states: {}
- name: qtgui_waterfall_sink_x_4_0_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: slot_width
    fc: slot_width * 0.5
    fftsize: '1024'
    grid: 'True'
    gui_hint: '[5,0,1,1]'
    legend: 'False'
    type: complex
    update_time: waterfall_update_band
  states: {}
- name: qtgui_waterfall_sink_x_4_0_0_0_0_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: slot_width
    fc: slot_width * 0.5
    fftsize: '1024'
    grid: 'True'
    gui_hint: '[5,1,1,1]'
    label1: 10M
    legend: 'False'
    type: complex
    update_time: waterfall_update_band
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: ''
    bw0: rf_bandwidth
    center_freq0: rf_center
    clock_source0: gpsdo
    dev_addr: type=x300
    gain0: rf_gain
    samp_rate: rf_samp_rate
    sd_spec0: B:0
    sync: gps_time
    time_source0: gpsdo
    type: fc32
  states: {}

connections:
- [freq_xlating_fir_filter_xxx_0, '0', network_udp_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_1, '0']
- [freq_xlating_fir_filter_xxx_1, '0', network_udp_sink_1, '0']
- [freq_xlating_fir_filter_xxx_1, '0', qtgui_waterfall_sink_x_2, '0']
- [freq_xlating_fir_filter_xxx_2, '0', network_udp_sink_2, '0']
- [freq_xlating_fir_filter_xxx_2, '0', qtgui_waterfall_sink_x_3, '0']
- [freq_xlating_fir_filter_xxx_3, '0', network_udp_sink_3, '0']
- [freq_xlating_fir_filter_xxx_3, '0', qtgui_waterfall_sink_x_4, '0']
- [freq_xlating_fir_filter_xxx_3_0, '0', network_udp_sink_3_0, '0']
- [freq_xlating_fir_filter_xxx_3_0, '0', qtgui_waterfall_sink_x_4_0, '0']
- [freq_xlating_fir_filter_xxx_3_0_0, '0', network_udp_sink_3_0_0, '0']
- [freq_xlating_fir_filter_xxx_3_0_0, '0', qtgui_waterfall_sink_x_4_0_0, '0']
- [freq_xlating_fir_filter_xxx_3_0_0_0, '0', network_udp_sink_3_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_3_0_0_0, '0', qtgui_waterfall_sink_x_4_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_3_0_0_0_0, '0', network_udp_sink_3_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_3_0_0_0_0, '0', qtgui_waterfall_sink_x_4_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_3_0_0_0_0_0, '0', network_udp_sink_3_0_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_3_0_0_0_0_0, '0', qtgui_waterfall_sink_x_4_0_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_3_0_0_0_0_0_0, '0', network_udp_sink_3_0_0_0_0_0_0, '0']
- [freq_xlating_fir_filter_xxx_3_0_0_0_0_0_0, '0', qtgui_waterfall_sink_x_4_0_0_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_1, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_2, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_3, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_3_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_3_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_3_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_3_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_3_0_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', freq_xlating_fir_filter_xxx_3_0_0_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
